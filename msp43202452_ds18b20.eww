<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msp43202452_ds18b20.ewp</path>
  </project>
  <batchBuild/>
</workspace>


